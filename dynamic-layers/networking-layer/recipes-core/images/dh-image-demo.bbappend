IMAGE_INSTALL:append:dh-dhsom = " \
	phytool \
	"

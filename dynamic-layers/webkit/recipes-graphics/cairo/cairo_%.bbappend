PACKAGECONFIG_append_dh-stm32mp1-dhsom = " egl glesv2 "

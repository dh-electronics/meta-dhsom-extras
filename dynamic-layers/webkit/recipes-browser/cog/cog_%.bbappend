PACKAGECONFIG:append:dh-dhsom = " dbus"

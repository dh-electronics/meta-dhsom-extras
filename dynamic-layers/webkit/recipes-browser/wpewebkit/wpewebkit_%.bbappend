PACKAGECONFIG:append:dh-dhsom = " lbse"
EXTRA_OECMAKE:append:dh-dhsom = " -DUSE_GSTREAMER_NATIVE_VIDEO=ON"

IMAGE_INSTALL:append:dh-dhsom = " \
	neverball neverball-data \
	"

RDEPENDS:${PN}:remove:dh-imx8m-dhsom = "cryptodev-module cryptodev-tests"

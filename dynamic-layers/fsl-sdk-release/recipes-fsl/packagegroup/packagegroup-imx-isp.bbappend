ISP_PKGS:remove:dh-imx8m-dhsom = "kernel-module-isp-vvcam"

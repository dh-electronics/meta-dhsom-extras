PACKAGECONFIG:append:dh-dhsom = " gles2 kmsdrm"

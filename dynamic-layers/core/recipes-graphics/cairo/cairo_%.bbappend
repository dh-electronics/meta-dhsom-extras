PACKAGECONFIG:append:dh-stm32mp1-dhsom = " egl glesv2 "
PACKAGECONFIG:remove:dh-stm32mp1-dhsom = "opengl"

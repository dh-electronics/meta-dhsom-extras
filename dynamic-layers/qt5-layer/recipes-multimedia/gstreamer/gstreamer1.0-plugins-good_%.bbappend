PACKAGECONFIG:append:dh-stm32mp1-dhsom = " qt5 "

IMAGE_INSTALL:append:dh-dhsom = " \
	flutter-auto \
	flutter-pi \
	packagegroup-meta-flutter-tests \
	"

REQUIRED_DISTRO_FEATURES:remove:dh-dhsom = "x11"

IMAGE_INSTALL:append:dh-dhsom = " nginx "

IMAGE_INSTALL:append:dh-imx8mp-dhsom = " python3-pillow tensorflow-lite"

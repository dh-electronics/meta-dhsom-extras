PACKAGECONFIG:append:dh-dhsom = " wayland-drm-egl-server-buffer "
PACKAGECONFIG:remove:dh-dhsom = "xcomposite-glx"

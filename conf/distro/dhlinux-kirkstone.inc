## conf/distro/dhlinux-scarthgap.inc
```bitbake
# OE 5.0 Scarthgap compatibility
DISTRO_FEATURES_BACKFILL_CONSIDERED += "sysvinit"
TCLIBCAPPEND = ""
```

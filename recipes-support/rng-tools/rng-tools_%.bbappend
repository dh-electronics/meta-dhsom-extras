FILESEXTRAPATHS:prepend:dh-dhsom := "${THISDIR}/${PN}:"

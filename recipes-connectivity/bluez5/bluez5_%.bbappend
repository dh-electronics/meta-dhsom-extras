CFLAGS:append:dh-dhsom = " -DFIRMWARE_DIR=\\"/lib/firmware\\""

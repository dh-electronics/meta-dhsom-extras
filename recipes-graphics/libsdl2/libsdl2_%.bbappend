PACKAGECONFIG:append:dh-dhsom = " gles2 kmsdrm"
PACKAGECONFIG_GL:dh-dhsom = "gles2"
